# Keil uVision project STM32_RDP_WRP.uvprojx, settings and files
target STM32_RDP_WRP (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32_RDP_WRP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ThirdUtils\dbger
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ThirdUtils/dbger
    ../ThirdUtils/dbger/: dbger.c
target STM32_RDP_WRP_SRAM (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: STM32_RDP_WRP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USER_VECT_TAB_ADDRESS,VECT_TAB_SRAM
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x2800
  memory RVCT9: RAM 0x20002800 size 0x2800
  scatter file: .\STM32_RDP_WRP_SRAM.sct
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDOUT 1.2.0
